FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
PRINC := "${@int(PRINC) + 1}"

SRCREV = "6a301b6ee0ae8c78fb704e1cd86f4e861070f641"

