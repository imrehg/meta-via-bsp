SRC_URI = "git://github.com/linux-can/can-utils.git;protocol=git"
