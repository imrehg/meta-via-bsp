SRC_URI = "git://github.com/viaembedded/qt-in-industrial-embedded.git"
